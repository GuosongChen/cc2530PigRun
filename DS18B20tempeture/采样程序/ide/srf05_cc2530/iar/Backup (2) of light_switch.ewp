# IAR project Backup (2) of light_switch.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/basicrf; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/cc8051; ../../../source/Components/targets/srf05_soc; ../../../source/Components/radios/cc2530
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: C:\Program Files\IAR Systems\Embedded Workbench 5.4\8051\config\lnk51ew_cc2530.xcl
  group application
    ../../../source/apps/AD_sample/: AD_sample.c ds18b20.c
  group basic rf
    ../../../source/Components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal/common
    ../../../source/Components/common/cc8051/: hal_cc8051.h
    ../../../source/Components/common/: hal_defs.h hal_int.c hal_types.h
    ../../../source/Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_digio.h hal_int.h hal_mcu.h
  group hal/rf
    ../../../source/Components/targets/interface/: hal_rf.h hal_rf_security.h
  group hal/rf/cc2530
    ../../../source/Components/radios/cc2530/: adc.c adc.h clock.c clock.h hal_mcu.c hal_rf.c hal_rf_security.c
  group hal/srf05_soc
    ../../../source/Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_digio.c
  group utilities
    ../../../source/Components/utils/: util.c util.h util_buffer.c util_buffer.h
